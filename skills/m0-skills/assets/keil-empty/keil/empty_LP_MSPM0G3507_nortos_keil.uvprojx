# Keil uVision project empty_LP_MSPM0G3507_nortos_keil.uvprojx, settings and files
target empty_LP_MSPM0G3507_nortos_keil (6230000::V6.23::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: empty_LP_MSPM0G3507_nortos_keil +hex
  BeforeMake: cmd.exe /C "D:\Downloads\ruanjianxiazai\ti\mspm0_sdk_2_04_00_06\tools\keil\syscfg.bat '$P' empty.syscfg"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: ..\..\..\..\..\ruanjianxiazai\ti\mspm0_sdk_2_04_00_06\source\third_party\CMSIS\Core\Include;..\..\..\..\..\ruanjianxiazai\ti\mspm0_sdk_2_04_00_06\source
  scatter file: ./mspm0g3507.sct
  link misc: D:\Downloads\ruanjianxiazai\ti\mspm0_sdk_2_04_00_06\source\ti\driverlib\lib\keil\m0p\mspm0g1x0x_g3x0x\driverlib.a
  group Source
    ../: empty.c empty.syscfg ti_msp_dl_config.h ti_msp_dl_config.c
    ./: startup_mspm0g350x_uvision.s
